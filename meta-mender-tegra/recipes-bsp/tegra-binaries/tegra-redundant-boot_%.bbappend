EXTRADEPS = "redundant-boot-overrides"
EXTRADEPS:tegra210 = ""
EXTRADEPS:tegra234 = ""
EXTRADEPS:tegra194 = ""
RDEPENDS:${PN} += "${EXTRADEPS}"

